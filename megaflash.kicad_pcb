# Repository pelrun/megaflash

## KiCad design megaflash.kicad_pcb

Parts:
C1: 100u
C2, C3, C4, C5: 10n
D1, D2, D3: DIODE
J1: CPC_EXTPORT
J2: PROG
J3: JTAG
LD1: RED
R1, R3: 1k
R2, R4: 10k
SW1: ~READ~/WRITE
SW2: ROM0ENABLE
SW3: ROM7ENABLE
U1: W29C040 or SST39V040
U2: XC9536PC44

Connections:
/A0: J1.18 (A0), J3.4, U1.12 (A0), U2.16 (TMS)
/A1: J1.17 (A1), J3.5, U1.11 (A1), U2.15 (TDI)
/A2: J1.16 (A2), U1.10 (A2)
/A3: J1.15 (A3), U1.9 (A3)
/A4: J1.14 (A4), U1.8 (A4)
/A5: J1.13 (A5), U1.7 (A5)
/A6: J1.12 (A6), U1.6 (A6)
/A7: J1.11 (A7), U1.5 (A7)
/A8: J1.10 (A8), U1.27 (A8)
/A9: J1.9 (A9), U1.26 (A9)
/A10: J1.8 (A10), U1.23 (A10)
/A11: J1.7 (A11), U1.25 (A11)
/A12: J1.6 (A12), U1.4 (A12)
/A13: J1.5 (A13), U1.28 (A13), U2.33 (M12)
/A14: U1.29 (A14), U2.35 (M10)
/A14EXT: J1.4 (A14), U2.43 (M4)
/A15: U1.3 (A15), U2.39 (I/O/GSR)
/A15EXT: J1.3 (A15), U2.28 (M14)
/A16: U1.2 (A16), U2.40 (I/O/GTS2)
/A17: U1.30 (A17), U2.37 (M8)
/A18: U1.1 (A18), U2.38 (M7)
/CLK: J1.50 (CLK4), U2.5 (I/O/GCK1)
/D0: J1.26 (D0), J2.4, U1.13 (D0), U2.18 (M13)
/D1: J1.25 (D1), U1.14 (D1), U2.19 (M14)
/D2: J1.24 (D2), U1.15 (D2), U2.20 (M15)
/D3: J1.23 (D3), U1.17 (D3), U2.22 (M16)
/D4: J1.22 (D4), U1.18 (D4), U2.24 (M17)
/D5: J1.21 (D5), U1.19 (D5), U2.25 (M17)
/D6: J1.20 (D6), U1.20 (D6), U2.26 (M16)
/D7: J1.19 (D7), U1.21 (D7), U2.27 (M15)
/ROM0EN: SW2.2, U2.44 (M2)
/ROM7EN: SW3.2, U2.42 (I/O/GTS1)
/ROMDIS: D1.1 (A), R1.2, U2.9 (M8)
/~CE: U1.22 (CE), U2.29 (M13)
/~IORQ: D2.1 (A), J1.31 (IORQ), U2.13 (M11)
/~MREQ: J1.28 (MREQ), U2.14 (M12)
/~RD: D3.1 (A), J1.32 (RD)
/~RD~WR: LD1.1 (A), R4.1, SW1.2, U2.2 (M1)
/~ROMEN: J1.42 (ROMEN), U1.24 (OE), U2.34 (M11)
/~WR: J1.33 (WR), U2.12 (M10)
/~WREN: U1.31 (WE), U2.36 (M9)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J1.2 (GND), J1.49 (GND), J3.1, R3.1, R4.2, SW1.1, SW2.1, SW3.1, U1.16 (GND), U2.10 (GND), U2.23 (GND), U2.31 (GND)
unnamed: D1.2 (K), J1.43 (ROMDIS)
unnamed: D2.2 (K), D3.2 (K), J2.2, R2.2
unnamed: J2.1, J3.3, U2.17 (TCK)
unnamed: J2.3, J3.6, U2.30 (TDO)
unnamed: LD1.2 (K), R3.2
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, J1.27 (VCC), J3.2, R1.1, R2.1, SW1.3, SW2.3, SW3.3, U1.32 (VCC), U2.21 (VCC), U2.32 (VCCIO), U2.41 (VCC)

Board: 2 copper layers, 72.6 x 43.4 mm, 21 parts (3 on the bottom side), 48 nets.

## Commit log

2014-04-17 Initial commit.
2014-04-17 Add png ver of schematic
2014-04-19 Nearly finished layout, tweaks/fixes on schematic.
2014-04-19 Fixed scrambled latch inputs. Board mostly routed.
2014-04-20 Updated images.
2014-04-20 Add component mapping.
2014-04-22 Completed v1 schematic and layout using XC9536 cpld.
2014-04-22 Replaced switch with one that's available from digikey.
2014-04-22 Added preliminary BOM
2014-04-23 Switch to the 3.3v XC9536XL (since the 5v XC9536 is unavailable)
